# Repository robkam/eeshow (continued)

## EAGLE design ee/cvt/modified_eagle_files/GTA04b7.brd (continued)

Schematic: GTA04b7.sch, sheet 23

Parts:
B1/CTL3709, B2/CTL2301, B3/\\3709, B4/A3709, B5/Q3709, B6/2301, B7/3709, B8/3709, B9/SPC2301, B10/OK3709, B11/ALT3709, B12/FN3709, B13/SPC2301, B14/SPC2301, B15/M3709, B16/,3709, B17/PGDN3709, B18/END3709, B19/LEFT3709, B20/RGHT3709, B21/DEL3709, B22/3709, B23/TAB3709, B24/BSP3709, B25/RET3709, B26/PIPE3709, B27/PGUP3709, B28/HOME3709, B29/UP3709, B30/DN3709, B31/ALT2301, B32/SHLCK3709, B33/ESC3709: BUTTONMAEANDER; N900-BUTTON
B60/^2301, B60/^3709, B69/O3709, B70/P3709, B79/2301, B80/2301: BUTTON-N900; N900-BUTTON
C2301: 100nF; SMD-0603
D2301, D2302, D2303, D2304, D2305, D2306, D2307, D2308: D0603; SMD-0603D
U2301: TCA8418RTW; LPCC-24

Connections:
1V8-CPU: C2301.1, U2301.21 (VCC); also elsewhere on the board
COL0_UPPER: B1/CTL3709.P$1 (A), B11/ALT3709.P$1 (A), B21/DEL3709.P$1 (A), B31/ALT2301.P$1 (A), U2301.9 (COL0)
COL1_UPPER: B2/CTL2301.P$1 (A), B12/FN3709.P$1 (A), B22/3709.P$1 (A), B32/SHLCK3709.P$1 (A), U2301.10 (COL1)
COL2_UPPER: B3/\\3709.P$1 (A), B13/SPC2301.P$1 (A), B23/TAB3709.P$1 (A), B33/ESC3709.P$1 (A), U2301.11 (COL2)
COL3_UPPER: B4/A3709.P$1 (A), B14/SPC2301.P$1 (A), B24/BSP3709.P$1 (A), U2301.12 (COL3)
COL4_UPPER: B5/Q3709.P$1 (A), B15/M3709.P$1 (A), B25/RET3709.P$1 (A), U2301.13 (COL4)
COL5_UPPER: B6/2301.P$1 (A), B16/,3709.P$1 (A), B26/PIPE3709.P$1 (A), U2301.14 (COL5)
COL6_UPPER: B7/3709.P$1 (A), B17/PGDN3709.P$1 (A), B27/PGUP3709.P$1 (A), U2301.15 (COL6)
COL7_UPPER: B8/3709.P$1 (A), B18/END3709.P$1 (A), B28/HOME3709.P$1 (A), U2301.16 (COL7)
COL8_UPPER: B9/SPC2301.P$1 (A), B19/LEFT3709.P$1 (A), B29/UP3709.P$1 (A), B60/^2301.P$1 (A), B69/O3709.P$1 (A), B79/2301.P$1 (A), U2301.17 (COL8)
COL9_UPPER: B10/OK3709.P$1 (A), B20/RGHT3709.P$1 (A), B30/DN3709.P$1 (A), B60/^3709.P$1 (A), B70/P3709.P$1 (A), B80/2301.P$1 (A), U2301.18 (COL9)
GND3: C2301.2, U2301.19 (GND); also elsewhere on the board
I2C2-SCL-CPU: U2301.23 (SCL); also elsewhere on the board
I2C2-SDA-CPU: U2301.22 (SDA); also elsewhere on the board
KEYIRQ_UPPER: U2301.24 (!INT)
unnamed: B1/CTL3709.P$2 (B), D2308.K
unnamed: B11/ALT3709.P$2 (B), D2306.K
unnamed: B21/DEL3709.P$2 (B), D2304.K
unnamed: B31/ALT2301.P$2 (B), D2302.K
unnamed: B2/CTL2301.P$2 (B), D2307.K
unnamed: B12/FN3709.P$2 (B), D2305.K
unnamed: B22/3709.P$2 (B), D2303.K
unnamed: B32/SHLCK3709.P$2 (B), D2301.K
RESET_UPPER: U2301.20 (!RESET)
ROW0_UPPER: B3/\\3709.P$2 (B), B4/A3709.P$2 (B), B5/Q3709.P$2 (B), B6/2301.P$2 (B), B7/3709.P$2 (B), B8/3709.P$2 (B), B9/SPC2301.P$2 (B), B10/OK3709.P$2 (B), D2307.A, D2308.A, U2301.8 (ROW0)
ROW1_UPPER: B13/SPC2301.P$2 (B), B14/SPC2301.P$2 (B), B15/M3709.P$2 (B), B16/,3709.P$2 (B), B17/PGDN3709.P$2 (B), B18/END3709.P$2 (B), B19/LEFT3709.P$2 (B), B20/RGHT3709.P$2 (B), D2305.A, D2306.A, U2301.7 (ROW1)
ROW2_UPPER: B23/TAB3709.P$2 (B), B24/BSP3709.P$2 (B), B25/RET3709.P$2 (B), B26/PIPE3709.P$2 (B), B27/PGUP3709.P$2 (B), B28/HOME3709.P$2 (B), B29/UP3709.P$2 (B), B30/DN3709.P$2 (B), D2303.A, D2304.A, U2301.6 (ROW2)
ROW3_UPPER: B33/ESC3709.P$2 (B), D2301.A, D2302.A, U2301.5 (ROW3)
ROW4_UPPER: U2301.4 (ROW4)
ROW5_UPPER: B60/^2301.P$2 (B), B60/^3709.P$2 (B), U2301.3 (ROW5)
ROW6_UPPER: B69/O3709.P$2 (B), B70/P3709.P$2 (B), U2301.2 (ROW6)
ROW7_UPPER: B79/2301.P$2 (B), B80/2301.P$2 (B), U2301.1 (ROW7)

Notes on the sheet:
Keypad
(c) 2014 Golden Delicious Computers GmbH&Co. KG. Licensed under CC-BY-SA.
Address: 0x34
needs final tuning (which button on which position)
VOL+ and VOL- could drive FETs sitting in the matrix
replace by 2x RB521ZS8A30 for space constraints
V2b

Schematic: GTA04b7.sch, sheet 24

Parts:
C2401: 4u7; SMD-0603
C2402, C2404, C2410: 100n; SMD-0402
C2403, C2405: 27p; SMD-0402
C2406, C2407, C2408, C2409: 1n; SMD-0603
C2411: 100nF; SMD-0402
L2401, L2402: tbd; MPZ1608
M2401, M2402: SPK0415HM4H; SPK0415HM4H-B
P-DISP3709: N900-DISPLAY; 500024-6471
R2401: 10R; SMD-0402
R2402, R2403: 560R;1%; SMD-0402
U2401: TSC2007IPW; TSSOP16
U2402: CRTOUCH; QFN-32+E-0.5

Connections:
1V8-CPU: C2401.1, R2401.1; also elsewhere on the board
DMIC_BIAS: L2401.2, L2402.2
DMIC_CLOCK: C2403.1, C2405.1
DMIC_DATA: M2401.4 (OUT), M2402.4 (OUT)
GND3: C2401.2, C2402.2, C2403.2, C2404.2, C2405.2, C2406.1, C2407.1, C2408.1, C2409.1, C2410.2, C2411.2, M2401.2 (L/R), M2401.5 (GND), M2401.6 (GND), M2401.7 (GND), M2401.8 (GND), M2402.5 (GND), M2402.6 (GND), M2402.7 (GND), M2402.8 (GND), U2401.6 (GND), U2401.13 (A1), U2401.14 (A0), U2402.8 (VSSA), U2402.14 (VSS), U2402.23 (ADDRSEL), U2402.25 (VSS), U2402.EXP (SHIELD); also elsewhere on the board
I2C2-SCL-CPU: U2401.12 (SCL), U2402.27 (SCL); also elsewhere on the board
I2C2-SDA-CPU: U2401.11 (SDA), U2402.26 (SDA); also elsewhere on the board
unnamed: C2407.2, P-DISP3709.40 (YU), U2401.3 (Y+), U2402.4 (Y+/5WLR)
unnamed: C2408.2, P-DISP3709.43 (YL), R2402.1, U2401.5 (Y-), U2402.6 (Y-/5WUL)
unnamed: C2406.2, P-DISP3709.44 (XR), U2401.4 (X-), U2402.5 (X+/5WS)
unnamed: C2409.2, P-DISP3709.41 (XL), R2403.1, U2401.2 (X+), U2402.15 (X-/5WLL)
unnamed: C2410.1, C2411.1, R2401.2, U2401.1 (VDD/REF), U2402.7 (VDDA), U2402.24 (VDD)
unnamed: R2402.2, U2402.1 (YR)
unnamed: R2403.2, U2402.17 (XR)
unnamed: C2402.1, L2401.1, M2401.1 (VDD)
unnamed: C2404.1, L2402.1, M2402.1 (VDD), M2402.2 (L/R)
PENIRQ_UPPER: U2401.10 (!PENIRQ), U2402.2 (TPENDING)
VREG_IN: U2402.12 (VREG_IN)
VREG_OUT: U2402.13 (VREG_OUT)

Notes on the sheet:
Display-Peripherals
(c) 2014 Golden Delicious Computers GmbH&Co. KG. Licensed under CC-BY-SA.
V2b
install alternatively!
Resistive Touch (display connector)

Schematic: GTA04b7.sch, sheet 25

Parts:
C2501: 4u7; MK325
C2502: 4.7u;50V;TMK325B7475MG; MK325
D2501: RSX101M-30; CRS02
D2502: 22V,200mW,MM5Z22V; SMD-0603D
L2501: 10uH,450mA,BRC2016T100K; LB2016
L2502, L2503, L2504: ACM2012H
P-DISP3709: N900-DISPLAY; 500024-6471
R2501: 330R; SMD-0402
R2502: DNP; SMD-0402
R2503, R2504: 62R; SMD-0603
U2501: TPS61041DBV; SOT23-5
U2502: DM3730CBP100; PBGA784-N515-0.4

Connections:
1V8-CPU: P-DISP3709.24 (DISP-1V8); also elsewhere on the board
2V5_UPPER: P-DISP3709.9 (VAMB-2V5)
2V8_UPPER: P-DISP3709.26 (DISP-2V8)
CAM-CLK: P-DISP3709.59 (CAM-EXTCLK); also elsewhere on the board
CAP_VDD_DSI: U2502.AH20 (CAP_VDD_DSI)
CAP_VDD_SRAM_CORE: U2502.L21 (CAP_VDD_SRAM_CORE)
CAP_VDD_SRAM_MPU_IVA: U2502.V4 (CAP_VDD_SRAM_MPU_IVA)
CAP_VDD_WKUP: U2502.AA15 (CAP_VDD_WKUP)
CDP-CLK+_UPPER: L2504.1 (A1), U2502.AC27 (DSS_D22)
CDP-CLK-_UPPER: L2504.2 (B1), U2502.AC28 (DSS_D23)
CDP-D0+_UPPER: L2502.1 (A1), U2502.AD27 (DSS_D11)
CDP-D0-_UPPER: L2502.2 (B1), U2502.AD28 (DSS_D10)
CDP-D1+_UPPER: L2503.1 (A1), U2502.AB27 (DSS_D13)
CDP-D1-_UPPER: L2503.2 (B1), U2502.AB28 (DSS_D12)
EAR+_UPPER: P-DISP3709.6
EAR-_UPPER: P-DISP3709.5 (N)
GND3: C2501.2, C2502.2, P-DISP3709.1 (GND), P-DISP3709.2 (GND), P-DISP3709.3 (GND), P-DISP3709.4 (GND), P-DISP3709.7 (GND), P-DISP3709.11 (GND), P-DISP3709.14 (GND), P-DISP3709.16 (GND), P-DISP3709.18 (GND), P-DISP3709.20 (GND), P-DISP3709.21 (GND), P-DISP3709.23 (GND), P-DISP3709.25 (GND), P-DISP3709.27 (GND), P-DISP3709.32 (GND), P-DISP3709.33 (GND), P-DISP3709.39 (GND), P-DISP3709.42 (GND), P-DISP3709.45 (GND), P-DISP3709.52 (GND), P-DISP3709.55 (GND), P-DISP3709.58 (GND), P-DISP3709.60 (GND), P-DISP3709.M1 (SHIELD), P-DISP3709.M2 (SHIELD), P-DISP3709.M3 (SHIELD), P-DISP3709.M4 (SHIELD), R2502.2, R2503.1, R2504.1, U2501.2 (GND); also elsewhere on the board
GPIO97: P-DISP3709.15 (CAM-SHUTDN); also elsewhere on the board
I2C2-SCL-CPU: P-DISP3709.13 (SCL); also elsewhere on the board
I2C2-SDA-CPU: P-DISP3709.12 (SDA); also elsewhere on the board
unnamed: L2504.3 (B2), P-DISP3709.49 (CLK-)
unnamed: L2504.4 (A2), P-DISP3709.48 (CLK+)
unnamed: L2503.3 (B2), P-DISP3709.47 (D1-)
unnamed: L2503.4 (A2), P-DISP3709.46 (D1+)
unnamed: L2502.3 (B2), P-DISP3709.51 (D0-)
unnamed: L2502.4 (A2), P-DISP3709.50 (D0+)
unnamed: P-DISP3709.38 (CLK), U2502.AB3 (CLK)
unnamed: P-DISP3709.36 (SIMO), U2502.AA4 (SOMI)
unnamed: P-DISP3709.35 (SOMI), U2502.AB4 (SIMO)
unnamed: P-DISP3709.34 (CS), U2502.AC2 (CS)
unnamed: P-DISP3709.37 (RESET), U2502.E28 (DSS_D20)
unnamed: P-DISP3709.10 (OPT-SW), U2502.H25 (DSS_D19)
unnamed: P-DISP3709.8 (AMB-INT), U2502.AG22 (DSS_D0)
unnamed: D2502.A, R2501.1, U2501.3 (FB)
unnamed: P-DISP3709.29 (LED-), R2504.2
unnamed: D2501.A, L2501.1, U2501.1 (SW)
unnamed: C2502.1, D2501.K, D2502.K, P-DISP3709.28 (LED+), P-DISP3709.31 (LED+)
unnamed: P-DISP3709.30 (LED-), R2501.2, R2503.2
POP_DDR_VDD_FT: U2502.A15 (POP_DDR_VDD_FT), U2502.AE28 (POP_DDR_VDD_FT), U2502.AF28 (POP_DDR_VDD_FT), U2502.J28 (POP_DDR_VDD_FT), U2502.M1 (POP_DDR_VDD_FT)
POP_FLASH_VDD_FT: U2502.AA1 (POP_FLASH_VDD_FT), U2502.AF1 (POP_FLASH_VDD_FT), U2502.AH10 (POP_FLASH_VDD_FT), U2502.AH15 (POP_FLASH_VDD_FT), U2502.N1 (POP_FLASH_VDD_FT)
POP_VSS_FT: U2502.AA2 (POP_VSS_FT), U2502.AF2 (POP_VSS_FT), U2502.AF27 (POP_VSS_FT), U2502.AG10 (POP_VSS_FT), U2502.AG15 (POP_VSS_FT), U2502.B15 (POP_VSS_FT), U2502.J27 (POP_VSS_FT), U2502.M2 (POP_VSS_FT), U2502.M26 (POP_VSS_FT), U2502.N2 (POP_VSS_FT)
PWM_UPPER: R2502.1, U2501.4 (EN)
VBATT_UPPER: C2501.1, L2501.2, U2501.5 (VIN); also elsewhere on the board
VDDA_DAC: U2502.V25 (VDDA_DAC)
VDDS: U2502.AD3 (VDDS), U2502.AD4 (VDDS), U2502.AE8 (VDDS), U2502.AE16 (VDDS), U2502.AE23 (VDDS), U2502.AF8 (VDDS), U2502.AF16 (VDDS), U2502.AF23 (VDDS), U2502.AG27 (VDDS), U2502.F25 (VDDS), U2502.F26 (VDDS), U2502.W4 (VDDS)
VDDS_CSI2: U2502.AG20 (VDDS_CSI2)
VDDS_CSIB: U2502.H28 (VDDS_CSIB)
VDDS_DPLL_DLL: U2502.K15 (VDDS_DPLL_DLL)
VDDS_DPLL_PER: U2502.AA16 (VDDS_DPLL_PER)
VDDS_DSI: U2502.AG21 (VDDS_DSI)
VDDS_MEM: U2502.A5 (VDDS_MEM), U2502.A8 (VDDS_MEM), U2502.A12 (VDDS_MEM), U2502.A18 (VDDS_MEM), U2502.A22 (VDDS_MEM), U2502.AH6 (VDDS_MEM), U2502.B5 (VDDS_MEM), U2502.B8 (VDDS_MEM), U2502.B12 (VDDS_MEM), U2502.B18 (VDDS_MEM), U2502.B22 (VDDS_MEM), U2502.C16 (VDDS_MEM), U2502.C28 (VDDS_MEM), U2502.D16 (VDDS_MEM), U2502.F1 (VDDS_MEM), U2502.F2 (VDDS_MEM), U2502.G28 (VDDS_MEM), U2502.J1 (VDDS_MEM), U2502.J2 (VDDS_MEM), U2502.R4 (VDDS_MEM), U2502.U1 (VDDS_MEM)
VDDS_MMC1: U2502.K25 (VDDS_MMC1)
VDDS_SDI: U2502.AE27 (VDDS_SDI)
VDDS_SIM: U2502.P25 (VDDS_SIM)
VDDS_SRAM: U2502.W16 (VDDS_SRAM)
VDDS_WKUP_BG: U2502.AA14 (VDDS_WKUP_BG)
VDD_CORE: U2502.AC4 (VDD_CORE), U2502.AE9 (VDD_CORE), U2502.AE18 (VDD_CORE), U2502.AE19 (VDD_CORE), U2502.AE24 (VDD_CORE), U2502.D8 (VDD_CORE), U2502.D9 (VDD_CORE), U2502.D15 (VDD_CORE), U2502.D22 (VDD_CORE), U2502.D23 (VDD_CORE), U2502.E25 (VDD_CORE), U2502.H4 (VDD_CORE), U2502.J4 (VDD_CORE), U2502.J18 (VDD_CORE), U2502.J19 (VDD_CORE), U2502.J20 (VDD_CORE), U2502.K18 (VDD_CORE), U2502.K20 (VDD_CORE), U2502.L25 (VDD_CORE), U2502.M19 (VDD_CORE), U2502.M25 (VDD_CORE), U2502.N19 (VDD_CORE), U2502.N20 (VDD_CORE), U2502.P20 (VDD_CORE), U2502.T19 (VDD_CORE), U2502.U19 (VDD_CORE), U2502.U20 (VDD_CORE), U2502.V20 (VDD_CORE), U2502.W18 (VDD_CORE), U2502.W20 (VDD_CORE), U2502.Y16 (VDD_CORE), U2502.Y18 (VDD_CORE), U2502.Y19 (VDD_CORE), U2502.Y20 (VDD_CORE)
VDD_MPU_IVA: U2502.J9 (VDD_MPU_IVA), U2502.J10 (VDD_MPU_IVA), U2502.J11 (VDD_MPU_IVA), U2502.J14 (VDD_MPU_IVA), U2502.J15 (VDD_MPU_IVA), U2502.K11 (VDD_MPU_IVA), U2502.K13 (VDD_MPU_IVA), U2502.K14 (VDD_MPU_IVA), U2502.L9 (VDD_MPU_IVA), U2502.L10 (VDD_MPU_IVA), U2502.M9 (VDD_MPU_IVA), U2502.M10 (VDD_MPU_IVA), U2502.N10 (VDD_MPU_IVA), U2502.R9 (VDD_MPU_IVA), U2502.R10 (VDD_MPU_IVA), U2502.T9 (VDD_MPU_IVA), U2502.T10 (VDD_MPU_IVA), U2502.U10 (VDD_MPU_IVA), U2502.W9 (VDD_MPU_IVA), U2502.W11 (VDD_MPU_IVA), U2502.W12 (VDD_MPU_IVA), U2502.W15 (VDD_MPU_IVA), U2502.Y9 (VDD_MPU_IVA), U2502.Y10 (VDD_MPU_IVA), U2502.Y11 (VDD_MPU_IVA), U2502.Y14 (VDD_MPU_IVA), U2502.Y15 (VDD_MPU_IVA)
VSS: U2502.A3 (VSS), U2502.A26 (VSS), U2502.AC25 (VSS), U2502.AC26 (VSS), U2502.AE12 (VSS), U2502.AE20 (VSS), U2502.AF12 (VSS), U2502.AF20 (VSS), U2502.AG2 (VSS), U2502.AG3 (VSS), U2502.AG6 (VSS), U2502.B2 (VSS), U2502.B27 (VSS), U2502.C7 (VSS), U2502.C10 (VSS), U2502.C13 (VSS), U2502.C19 (VSS), U2502.C22 (VSS), U2502.D7 (VSS), U2502.D10 (VSS), U2502.D13 (VSS), U2502.D19 (VSS), U2502.D21 (VSS), U2502.E3 (VSS), U2502.E4 (VSS), U2502.G27 (VSS), U2502.J3 (VSS), U2502.J12 (VSS), U2502.J13 (VSS), U2502.J16 (VSS), U2502.J17 (VSS), U2502.K9 (VSS), U2502.K10 (VSS), U2502.K12 (VSS), U2502.K16 (VSS), U2502.K17 (VSS), U2502.K19 (VSS), U2502.L19 (VSS), U2502.L20 (VSS), U2502.L26 (VSS), U2502.M20 (VSS), U2502.N9 (VSS), U2502.P3 (VSS), U2502.P4 (VSS), U2502.P9 (VSS), U2502.P10 (VSS), U2502.P19 (VSS), U2502.R19 (VSS), U2502.R20 (VSS), U2502.R26 (VSS), U2502.T20 (VSS), U2502.U2 (VSS), U2502.U9 (VSS), U2502.V9 (VSS), U2502.V10 (VSS), U2502.V19 (VSS), U2502.W3 (VSS), U2502.W10 (VSS), U2502.W13 (VSS), U2502.W14 (VSS), U2502.W17 (VSS), U2502.W19 (VSS), U2502.W25 (VSS), U2502.Y12 (VSS), U2502.Y13 (VSS), U2502.Y17 (VSS), U2502.Y25 (VSS); also elsewhere on the board
VSSA_DAC: U2502.Y26 (VSSA_DAC)
VSS_CSI2: U2502.AG16 (VSS_CSI2)
VSS_CSIB: U2502.M28 (VSS_CSIB)
VSS_DSI: U2502.AH21 (VSS_DSI)
VSS_SDI: U2502.AA26 (VSS_SDI)

Notes on the sheet:
Display-Panel&Power
(c) 2014 Golden Delicious Computers GmbH&Co. KG. Licensed under CC-BY-SA.
connector pin assigment needs intensive review!!!
18V, 20mA each string
Adjust sense resistor+Z-Diode to voltage&current
Sony ACX565AKM
Check with data sheet of Sony ACX565AKM
V2b
Display Connector
not shown here:
Camera, Touch, LEDs

Schematic: GTA04b7.sch, sheet 26

Parts:
U2502: DM3730CBP100; PBGA784-N515-0.4
U2601: KCE00E00CA; NONE

Connections:
CAP_VDD_DSI: U2502.AH20 (CAP_VDD_DSI)
CAP_VDD_SRAM_CORE: U2502.L21 (CAP_VDD_SRAM_CORE)
CAP_VDD_SRAM_MPU_IVA: U2502.V4 (CAP_VDD_SRAM_MPU_IVA)
CAP_VDD_WKUP: U2502.AA15 (CAP_VDD_WKUP)
I2C2-SCL-CPU: U2502.AF15 (SCL); also elsewhere on the board
I2C2-SDA-CPU: U2502.AE15 (SDA); also elsewhere on the board
I2C3-SCL-CPU: U2502.AF14 (SCL); also elsewhere on the board
I2C3-SDA-CPU: U2502.AG14 (SDA); also elsewhere on the board
NRESWARM-CPU: U2502.AF24 (SYS_NRESWARM); also elsewhere on the board
POP_DDR_VDD_FT: U2502.A15 (POP_DDR_VDD_FT), U2502.AE28 (POP_DDR_VDD_FT), U2502.AF28 (POP_DDR_VDD_FT), U2502.J28 (POP_DDR_VDD_FT), U2502.M1 (POP_DDR_VDD_FT)
POP_FLASH_VDD_FT: U2502.AA1 (POP_FLASH_VDD_FT), U2502.AF1 (POP_FLASH_VDD_FT), U2502.AH10 (POP_FLASH_VDD_FT), U2502.AH15 (POP_FLASH_VDD_FT), U2502.N1 (POP_FLASH_VDD_FT)
POP_VSS_FT: U2502.AA2 (POP_VSS_FT), U2502.AF2 (POP_VSS_FT), U2502.AF27 (POP_VSS_FT), U2502.AG10 (POP_VSS_FT), U2502.AG15 (POP_VSS_FT), U2502.B15 (POP_VSS_FT), U2502.J27 (POP_VSS_FT), U2502.M2 (POP_VSS_FT), U2502.M26 (POP_VSS_FT), U2502.N2 (POP_VSS_FT)
VDDA_DAC: U2502.V25 (VDDA_DAC)
VDDS: U2502.AD3 (VDDS), U2502.AD4 (VDDS), U2502.AE8 (VDDS), U2502.AE16 (VDDS), U2502.AE23 (VDDS), U2502.AF8 (VDDS), U2502.AF16 (VDDS), U2502.AF23 (VDDS), U2502.AG27 (VDDS), U2502.F25 (VDDS), U2502.F26 (VDDS), U2502.W4 (VDDS)
VDDS_CSI2: U2502.AG20 (VDDS_CSI2)
VDDS_CSIB: U2502.H28 (VDDS_CSIB)
VDDS_DPLL_DLL: U2502.K15 (VDDS_DPLL_DLL)
VDDS_DPLL_PER: U2502.AA16 (VDDS_DPLL_PER)
VDDS_DSI: U2502.AG21 (VDDS_DSI)
VDDS_MEM: U2502.A5 (VDDS_MEM), U2502.A8 (VDDS_MEM), U2502.A12 (VDDS_MEM), U2502.A18 (VDDS_MEM), U2502.A22 (VDDS_MEM), U2502.AH6 (VDDS_MEM), U2502.B5 (VDDS_MEM), U2502.B8 (VDDS_MEM), U2502.B12 (VDDS_MEM), U2502.B18 (VDDS_MEM), U2502.B22 (VDDS_MEM), U2502.C16 (VDDS_MEM), U2502.C28 (VDDS_MEM), U2502.D16 (VDDS_MEM), U2502.F1 (VDDS_MEM), U2502.F2 (VDDS_MEM), U2502.G28 (VDDS_MEM), U2502.J1 (VDDS_MEM), U2502.J2 (VDDS_MEM), U2502.R4 (VDDS_MEM), U2502.U1 (VDDS_MEM)
VDDS_MMC1: U2502.K25 (VDDS_MMC1)
VDDS_SDI: U2502.AE27 (VDDS_SDI)
VDDS_SIM: U2502.P25 (VDDS_SIM)
VDDS_SRAM: U2502.W16 (VDDS_SRAM)
VDDS_WKUP_BG: U2502.AA14 (VDDS_WKUP_BG)
VDD_CORE: U2502.AC4 (VDD_CORE), U2502.AE9 (VDD_CORE), U2502.AE18 (VDD_CORE), U2502.AE19 (VDD_CORE), U2502.AE24 (VDD_CORE), U2502.D8 (VDD_CORE), U2502.D9 (VDD_CORE), U2502.D15 (VDD_CORE), U2502.D22 (VDD_CORE), U2502.D23 (VDD_CORE), U2502.E25 (VDD_CORE), U2502.H4 (VDD_CORE), U2502.J4 (VDD_CORE), U2502.J18 (VDD_CORE), U2502.J19 (VDD_CORE), U2502.J20 (VDD_CORE), U2502.K18 (VDD_CORE), U2502.K20 (VDD_CORE), U2502.L25 (VDD_CORE), U2502.M19 (VDD_CORE), U2502.M25 (VDD_CORE), U2502.N19 (VDD_CORE), U2502.N20 (VDD_CORE), U2502.P20 (VDD_CORE), U2502.T19 (VDD_CORE), U2502.U19 (VDD_CORE), U2502.U20 (VDD_CORE), U2502.V20 (VDD_CORE), U2502.W18 (VDD_CORE), U2502.W20 (VDD_CORE), U2502.Y16 (VDD_CORE), U2502.Y18 (VDD_CORE), U2502.Y19 (VDD_CORE), U2502.Y20 (VDD_CORE)
VDD_MPU_IVA: U2502.J9 (VDD_MPU_IVA), U2502.J10 (VDD_MPU_IVA), U2502.J11 (VDD_MPU_IVA), U2502.J14 (VDD_MPU_IVA), U2502.J15 (VDD_MPU_IVA), U2502.K11 (VDD_MPU_IVA), U2502.K13 (VDD_MPU_IVA), U2502.K14 (VDD_MPU_IVA), U2502.L9 (VDD_MPU_IVA), U2502.L10 (VDD_MPU_IVA), U2502.M9 (VDD_MPU_IVA), U2502.M10 (VDD_MPU_IVA), U2502.N10 (VDD_MPU_IVA), U2502.R9 (VDD_MPU_IVA), U2502.R10 (VDD_MPU_IVA), U2502.T9 (VDD_MPU_IVA), U2502.T10 (VDD_MPU_IVA), U2502.U10 (VDD_MPU_IVA), U2502.W9 (VDD_MPU_IVA), U2502.W11 (VDD_MPU_IVA), U2502.W12 (VDD_MPU_IVA), U2502.W15 (VDD_MPU_IVA), U2502.Y9 (VDD_MPU_IVA), U2502.Y10 (VDD_MPU_IVA), U2502.Y11 (VDD_MPU_IVA), U2502.Y14 (VDD_MPU_IVA), U2502.Y15 (VDD_MPU_IVA)
VSS: U2502.A3 (VSS), U2502.A26 (VSS), U2502.AC25 (VSS), U2502.AC26 (VSS), U2502.AE12 (VSS), U2502.AE20 (VSS), U2502.AF12 (VSS), U2502.AF20 (VSS), U2502.AG2 (VSS), U2502.AG3 (VSS), U2502.AG6 (VSS), U2502.B2 (VSS), U2502.B27 (VSS), U2502.C7 (VSS), U2502.C10 (VSS), U2502.C13 (VSS), U2502.C19 (VSS), U2502.C22 (VSS), U2502.D7 (VSS), U2502.D10 (VSS), U2502.D13 (VSS), U2502.D19 (VSS), U2502.D21 (VSS), U2502.E3 (VSS), U2502.E4 (VSS), U2502.G27 (VSS), U2502.J3 (VSS), U2502.J12 (VSS), U2502.J13 (VSS), U2502.J16 (VSS), U2502.J17 (VSS), U2502.K9 (VSS), U2502.K10 (VSS), U2502.K12 (VSS), U2502.K16 (VSS), U2502.K17 (VSS), U2502.K19 (VSS), U2502.L19 (VSS), U2502.L20 (VSS), U2502.L26 (VSS), U2502.M20 (VSS), U2502.N9 (VSS), U2502.P3 (VSS), U2502.P4 (VSS), U2502.P9 (VSS), U2502.P10 (VSS), U2502.P19 (VSS), U2502.R19 (VSS), U2502.R20 (VSS), U2502.R26 (VSS), U2502.T20 (VSS), U2502.U2 (VSS), U2502.U9 (VSS), U2502.V9 (VSS), U2502.V10 (VSS), U2502.V19 (VSS), U2502.W3 (VSS), U2502.W10 (VSS), U2502.W13 (VSS), U2502.W14 (VSS), U2502.W17 (VSS), U2502.W19 (VSS), U2502.W25 (VSS), U2502.Y12 (VSS), U2502.Y13 (VSS), U2502.Y17 (VSS), U2502.Y25 (VSS); also elsewhere on the board
VSSA_DAC: U2502.Y26 (VSSA_DAC)
VSS_CSI2: U2502.AG16 (VSS_CSI2)
VSS_CSIB: U2502.M28 (VSS_CSIB)
VSS_DSI: U2502.AH21 (VSS_DSI)
VSS_SDI: U2502.AA26 (VSS_SDI)

Notes on the sheet:
CPU + PoP RAM/NAND
(c) 2014 Golden Delicious Computers GmbH&Co. KG. Licensed under CC-BY-SA.
INCOMPLETE in V2
V2b

Schematic: GTA04b7.sch, sheet 27

Parts:
U2701: EMMC-169; EMMC-BGA-N169-0.5

Connections:
1V8-CPU: U2701.AA3 (VCCQ), U2701.AA5 (VCCQ), U2701.K6 (VCCQ), U2701.W4 (VCCQ), U2701.Y4 (VCCQ); also elsewhere on the board
3V3-CPU: U2701.M6 (VCC), U2701.N5 (VCC), U2701.T10 (VCC), U2701.U9 (VCC); also elsewhere on the board
GND3: U2701.AA4 (VSSQ), U2701.AA6 (VSSQ), U2701.K4 (VSSQ), U2701.M7 (VSS), U2701.P5 (VSS), U2701.R10 (VSS), U2701.U8 (VSS), U2701.Y2 (VSSQ), U2701.Y5 (VSSQ); also elsewhere on the board

Notes on the sheet:
eMMC
(c) 2014 Golden Delicious Computers GmbH&Co. KG. Licensed under CC-BY-SA.
INCOMPLETE in V2
V2b
to some 1.8V MMC interface
nreswarm

Schematic: GTA04b7.sch, sheet 28

Parts:
C2801: tbd; SMD-1206
C2802: PAS3225P3R3113; SMD-1210
R2801: (0R); SMD-0603
U2801: LTC3355; NONE
U2802: USB3322; WLCSP25-N25-0.4
U2803: TPS65950; PBGA256-N213-0.4

Connections:
AVSS1: U2803.E5 (AVSS1), U2803.J4 (AVSS1), U2803.J6 (AVSS1), U2803.J7 (AVSS1), U2803.J8 (AVSS1)
AVSS2: U2803.R10 (AVSS2)
AVSS3: U2803.M15 (AVSS3)
AVSS4: U2803.C7 (AVSS4)
CP.GND: U2803.R6 (CP.GND)
CP.IN: U2803.R7 (CP.IN)
DGND: U2803.H9 (DGND), U2803.H10 (DGND), U2803.H11 (DGND), U2803.H13 (DGND)
GND3: C2801.2 (-), C2802.2; also elsewhere on the board
GND.LEFT: U2803.C9 (GND.LEFT), U2803.C10 (GND.LEFT)
GND.RIGHT: U2803.C11 (GND.RIGHT), U2803.C12 (GND.RIGHT)
IO.1P8: U2803.C8 (IO.1P8)
LEDGND: U2803.F16 (LEDGND)
MICBIAS.GND: U2803.D3 (MICBIAS.GND)
MODEM-CPU-D+: U2802.E1 (DP); also elsewhere on the board
MODEM-CPU-D-: U2802.D1 (DM); also elsewhere on the board
unnamed: C2802.1, U2803.M14 (BKBAT)
OTG-CPU-D+: U2803.T10 (DP/UART3.RXD); also elsewhere on the board
OTG-CPU-D-: U2803.T11 (DN/UART3.TXD); also elsewhere on the board
OTG-CPU-ID: U2803.R11 (ID)
VAUX1.OUT: U2803.M2 (VAUX1.OUT)
VAUX2.OUT: U2803.M3 (VAUX2.OUT)
VAUX3.OUT: U2803.G16 (VAUX3.OUT)
VAUX4.IN: U2803.B2 (VAUX4.IN)
VAUX4.OUT: U2803.B3 (VAUX4.OUT)
VAUX12S.IN: U2803.L1 (VAUX12S.IN)
VBAT: U2803.R5 (VBAT); also elsewhere on the board
VBAT(->TPS65950)_UPPER: R2801.2; also elsewhere on the board
VBAT.LEFT: U2803.D9 (VBAT.LEFT), U2803.D10 (VBAT.LEFT)
VBAT.RIGHT: U2803.D11 (VBAT.RIGHT), U2803.D12 (VBAT.RIGHT)
VBAT.USB: U2803.R9 (VBAT.USB)
VBUS-CPU: U2803.R8 (VBUS); also elsewhere on the board
VBUS-MODEM-CPU: U2802.C2 (VBUS); also elsewhere on the board
VDAC.IN: U2803.K1 (VDAC.IN)
VDAC.OUT2: U2803.L2 (VDAC.OUT2)
VDD1.FB: U2803.E13 (VDD1.FB)
VDD1.GND: U2803.B15 (VDD1.GND), U2803.C15 (VDD1.GND), U2803.C16 (VDD1.GND)
VDD1.IN: U2803.D14 (VDD1.IN), U2803.E14 (VDD1.IN), U2803.E15 (VDD1.IN)
VDD1.SW: U2803.C14 (VDD1.SW), U2803.D15 (VDD1.SW), U2803.D16 (VDD1.SW)
VDD2.FB: U2803.N13 (VDD2.FB)
VDD2.GND: U2803.R15 (VDD2.GND), U2803.T14 (VDD2.GND)
VDD2.IN: U2803.P14 (VDD2.IN), U2803.R13 (VDD2.IN)
VDD2.SW: U2803.R14 (VDD2.SW), U2803.T13 (VDD2.SW)
VINT.IN: U2803.K15 (VINT.IN)
VINTANA1.OUT: U2803.H3 (VINTANA1.OUT)
VINTANA2.OUT: U2803.B6 (VINTANA2.OUT), U2803.J2 (VINTANA2.OUT)
VINTDIG.OUT: U2803.L16 (VINTDIG.OUT)
VIO.FB: U2803.N3 (VIO.FB)
VIO.GND: U2803.R2 (VIO.GND), U2803.T3 (VIO.GND)
VIO.IN: U2803.P3 (VIO.IN), U2803.R4 (VIO.IN)
VIO.SW: U2803.R3 (VIO.SW), U2803.T4 (VIO.SW)
VMMC1.IN: U2803.C1 (VMMC1.IN)
VMMC1.OUT: U2803.C2 (VMMC1.OUT)
VMMC2.IN: U2803.A3 (VMMC2.IN)
VMMC2.OUT: U2803.A4 (VMMC2.OUT)
VPLL1.OUT: U2803.H14 (VPLL1.OUT)
VPLLA3R.IN: U2803.H15 (VPLLA3R.IN)
VREF: U2803.N16 (VREF)
VRTC.OUT: U2803.K16 (VRTC.OUT)
VSDI.CSI.OUT: U2803.J15 (VSDI.CSI.OUT)
VSIM.OUT: U2803.K2 (VSIM.OUT)
VSYS_UPPER: R2801.1; also elsewhere on the board

Notes on the sheet:
PMU+Codec
(c) 2014 Golden Delicious Computers GmbH&Co. KG. Licensed under CC-BY-SA.
INCOMPLETE in V2
should drive TPS65950
V2b
this goes through B2B to OTG socket
this goes through B2B to modem
needs a small charge pump to generate 5V 50mA.

Schematic: GTA04b7.sch, sheet 29

Parts:
N2901: 0R
U2901: TPS73633DBV; SOT23-5
U2902: TPS73618DBV; SOT23-5

Connections:
1V8-CPU: U2902.5 (OUT); also elsewhere on the board
3V3-CPU: N2901.P$1, U2901.5 (OUT); also elsewhere on the board
GND3: U2901.2 (GND), U2902.2 (GND); also elsewhere on the board
VBAT(->TPS65950)_UPPER: U2901.1 (IN), U2901.3 (EN), U2902.1 (IN), U2902.3 (EN); also elsewhere on the board
VMMC2-CPU: N2901.P$2

Notes on the sheet:
simple capless 400mA LDO for TPS65950 substitute
(only for prototype)
BB-XM Dummy (TWL4030)
(c) 2014 Golden Delicious Computers GmbH&Co. KG. Licensed under CC-BY-SA.
V2b

Schematic: GTA04b7.sch, sheet 30

Parts:
C3001, C3003: 27p; SMD-0402
C3002, C3004, C3005: 2u2; SMD-0402
C3006, C3007: 100n; SMD-0402
L3001: L0402; SMD-0402
N3001: N97-CAMERA
P3001: DF37NB-20DS-0.4/N97CAM; DF37NB-20SD-0.4V
P-DISP3709: N900-DISPLAY; 500024-6471
R3001, R3002: 47R; SMD-0402
R3003, R3004: 100R; SMD-0402
U2502: DM3730CBP100; PBGA784-N515-0.4
U3001, U3002: TS3DS26227; R-XBGA-N12-0.5
U3003: slide magnetic sensor; NONE

Connections:
1V8-CPU: C3003.1, C3004.1, P3001.12 (VIO), P3001.13 (VIO); also elsewhere on the board
CAM-CLK: R3002.2; also elsewhere on the board
CAM-STR: U2502.D25 (CAM_STROBE)
CAP_VDD_DSI: U2502.AH20 (CAP_VDD_DSI)
CAP_VDD_SRAM_CORE: U2502.L21 (CAP_VDD_SRAM_CORE)
CAP_VDD_SRAM_MPU_IVA: U2502.V4 (CAP_VDD_SRAM_MPU_IVA)
CAP_VDD_WKUP: U2502.AA15 (CAP_VDD_WKUP)
CSI-B-C+_UPPER: P-DISP3709.54 (CLK+), U3001.B1 (NO1)
CSI-B-C-_UPPER: P-DISP3709.53 (CLK-), U3001.B3 (NO2)
CSI-B-D+_UPPER: P-DISP3709.57 (DATA+), U3002.B1 (NO1)
CSI-B-D-_UPPER: P-DISP3709.56 (DATA-), U3002.B3 (NO2)
GND3: C3001.2, C3002.2, C3003.2, C3004.2, C3005.2, C3006.2, C3007.2, P3001.2 (GND), P3001.5 (GND), P3001.8 (GND), P3001.11 (GND), P3001.14 (GND), P3001.17 (GND), P3001.M1 (GND), P3001.M2 (GND), U3001.B2 (GND), U3001.C2 (GND), U3002.B2 (GND), U3002.C2 (GND); also elsewhere on the board
GPIO97: U2502.C27 (CAM_PCLK), U3001.A1 (IN1), U3001.A3 (IN2), U3002.A1 (IN1), U3002.A3 (IN2); also elsewhere on the board
GPIO102: P3001.18 (SHDN), U2502.C24 (CAM_D3)
GPIO167: U2502.B23 (CAM_WEN)
I2C3-SCL-CPU: P3001.19 (SCL); also elsewhere on the board
I2C3-SDA-CPU: P3001.20 (SDA); also elsewhere on the board
unnamed: R3001.1, R3002.1, U2502.C25 (CAM_XCLKA)
unnamed: R3003.2, U2502.K28 (CAM_D6), U3001.C1 (COM1)
unnamed: C3001.1, C3002.1, L3001.2, P3001.3 (VDDA), P3001.4 (VDDA)
unnamed: P3001.6 (DATA+), U3002.D1 (NC1)
unnamed: P3001.7 (DATA-), U3002.D3 (NC2)
unnamed: P3001.9 (CLK+), U3001.D1 (NC1)
unnamed: P3001.10 (CLK-), U3001.D3 (NC2)
unnamed: P3001.1 (CLK), R3001.2
unnamed: R3004.2, U2502.K27 (CAM_D8), U3002.C1 (COM1)
unnamed: R3004.1, U2502.L27 (CAM_D9), U3002.C3 (COM2)
unnamed: R3003.1, U2502.L28 (CAM_D7), U3001.C3 (COM2)
POP_DDR_VDD_FT: U2502.A15 (POP_DDR_VDD_FT), U2502.AE28 (POP_DDR_VDD_FT), U2502.AF28 (POP_DDR_VDD_FT), U2502.J28 (POP_DDR_VDD_FT), U2502.M1 (POP_DDR_VDD_FT)
POP_FLASH_VDD_FT: U2502.AA1 (POP_FLASH_VDD_FT), U2502.AF1 (POP_FLASH_VDD_FT), U2502.AH10 (POP_FLASH_VDD_FT), U2502.AH15 (POP_FLASH_VDD_FT), U2502.N1 (POP_FLASH_VDD_FT)
POP_VSS_FT: U2502.AA2 (POP_VSS_FT), U2502.AF2 (POP_VSS_FT), U2502.AF27 (POP_VSS_FT), U2502.AG10 (POP_VSS_FT), U2502.AG15 (POP_VSS_FT), U2502.B15 (POP_VSS_FT), U2502.J27 (POP_VSS_FT), U2502.M2 (POP_VSS_FT), U2502.M26 (POP_VSS_FT), U2502.N2 (POP_VSS_FT)
VAUX??: L3001.1
VBATT_UPPER: C3005.1, P3001.15 (VBAT), P3001.16 (VBAT); also elsewhere on the board
VCSI=VAUX2???: C3006.1, U3001.A2 (VIO), U3002.A2 (VIO)
VDDA: C3007.1, U3001.D2 (V+), U3002.D2 (V+)
VDDA_DAC: U2502.V25 (VDDA_DAC)
VDDS: U2502.AD3 (VDDS), U2502.AD4 (VDDS), U2502.AE8 (VDDS), U2502.AE16 (VDDS), U2502.AE23 (VDDS), U2502.AF8 (VDDS), U2502.AF16 (VDDS), U2502.AF23 (VDDS), U2502.AG27 (VDDS), U2502.F25 (VDDS), U2502.F26 (VDDS), U2502.W4 (VDDS)
VDDS_CSI2: U2502.AG20 (VDDS_CSI2)
VDDS_CSIB: U2502.H28 (VDDS_CSIB)
VDDS_DPLL_DLL: U2502.K15 (VDDS_DPLL_DLL)
VDDS_DPLL_PER: U2502.AA16 (VDDS_DPLL_PER)
VDDS_DSI: U2502.AG21 (VDDS_DSI)
VDDS_MEM: U2502.A5 (VDDS_MEM), U2502.A8 (VDDS_MEM), U2502.A12 (VDDS_MEM), U2502.A18 (VDDS_MEM), U2502.A22 (VDDS_MEM), U2502.AH6 (VDDS_MEM), U2502.B5 (VDDS_MEM), U2502.B8 (VDDS_MEM), U2502.B12 (VDDS_MEM), U2502.B18 (VDDS_MEM), U2502.B22 (VDDS_MEM), U2502.C16 (VDDS_MEM), U2502.C28 (VDDS_MEM), U2502.D16 (VDDS_MEM), U2502.F1 (VDDS_MEM), U2502.F2 (VDDS_MEM), U2502.G28 (VDDS_MEM), U2502.J1 (VDDS_MEM), U2502.J2 (VDDS_MEM), U2502.R4 (VDDS_MEM), U2502.U1 (VDDS_MEM)
VDDS_MMC1: U2502.K25 (VDDS_MMC1)
VDDS_SDI: U2502.AE27 (VDDS_SDI)
VDDS_SIM: U2502.P25 (VDDS_SIM)
VDDS_SRAM: U2502.W16 (VDDS_SRAM)
VDDS_WKUP_BG: U2502.AA14 (VDDS_WKUP_BG)
VDD_CORE: U2502.AC4 (VDD_CORE), U2502.AE9 (VDD_CORE), U2502.AE18 (VDD_CORE), U2502.AE19 (VDD_CORE), U2502.AE24 (VDD_CORE), U2502.D8 (VDD_CORE), U2502.D9 (VDD_CORE), U2502.D15 (VDD_CORE), U2502.D22 (VDD_CORE), U2502.D23 (VDD_CORE), U2502.E25 (VDD_CORE), U2502.H4 (VDD_CORE), U2502.J4 (VDD_CORE), U2502.J18 (VDD_CORE), U2502.J19 (VDD_CORE), U2502.J20 (VDD_CORE), U2502.K18 (VDD_CORE), U2502.K20 (VDD_CORE), U2502.L25 (VDD_CORE), U2502.M19 (VDD_CORE), U2502.M25 (VDD_CORE), U2502.N19 (VDD_CORE), U2502.N20 (VDD_CORE), U2502.P20 (VDD_CORE), U2502.T19 (VDD_CORE), U2502.U19 (VDD_CORE), U2502.U20 (VDD_CORE), U2502.V20 (VDD_CORE), U2502.W18 (VDD_CORE), U2502.W20 (VDD_CORE), U2502.Y16 (VDD_CORE), U2502.Y18 (VDD_CORE), U2502.Y19 (VDD_CORE), U2502.Y20 (VDD_CORE)
VDD_MPU_IVA: U2502.J9 (VDD_MPU_IVA), U2502.J10 (VDD_MPU_IVA), U2502.J11 (VDD_MPU_IVA), U2502.J14 (VDD_MPU_IVA), U2502.J15 (VDD_MPU_IVA), U2502.K11 (VDD_MPU_IVA), U2502.K13 (VDD_MPU_IVA), U2502.K14 (VDD_MPU_IVA), U2502.L9 (VDD_MPU_IVA), U2502.L10 (VDD_MPU_IVA), U2502.M9 (VDD_MPU_IVA), U2502.M10 (VDD_MPU_IVA), U2502.N10 (VDD_MPU_IVA), U2502.R9 (VDD_MPU_IVA), U2502.R10 (VDD_MPU_IVA), U2502.T9 (VDD_MPU_IVA), U2502.T10 (VDD_MPU_IVA), U2502.U10 (VDD_MPU_IVA), U2502.W9 (VDD_MPU_IVA), U2502.W11 (VDD_MPU_IVA), U2502.W12 (VDD_MPU_IVA), U2502.W15 (VDD_MPU_IVA), U2502.Y9 (VDD_MPU_IVA), U2502.Y10 (VDD_MPU_IVA), U2502.Y11 (VDD_MPU_IVA), U2502.Y14 (VDD_MPU_IVA), U2502.Y15 (VDD_MPU_IVA)
VSS: U2502.A3 (VSS), U2502.A26 (VSS), U2502.AC25 (VSS), U2502.AC26 (VSS), U2502.AE12 (VSS), U2502.AE20 (VSS), U2502.AF12 (VSS), U2502.AF20 (VSS), U2502.AG2 (VSS), U2502.AG3 (VSS), U2502.AG6 (VSS), U2502.B2 (VSS), U2502.B27 (VSS), U2502.C7 (VSS), U2502.C10 (VSS), U2502.C13 (VSS), U2502.C19 (VSS), U2502.C22 (VSS), U2502.D7 (VSS), U2502.D10 (VSS), U2502.D13 (VSS), U2502.D19 (VSS), U2502.D21 (VSS), U2502.E3 (VSS), U2502.E4 (VSS), U2502.G27 (VSS), U2502.J3 (VSS), U2502.J12 (VSS), U2502.J13 (VSS), U2502.J16 (VSS), U2502.J17 (VSS), U2502.K9 (VSS), U2502.K10 (VSS), U2502.K12 (VSS), U2502.K16 (VSS), U2502.K17 (VSS), U2502.K19 (VSS), U2502.L19 (VSS), U2502.L20 (VSS), U2502.L26 (VSS), U2502.M20 (VSS), U2502.N9 (VSS), U2502.P3 (VSS), U2502.P4 (VSS), U2502.P9 (VSS), U2502.P10 (VSS), U2502.P19 (VSS), U2502.R19 (VSS), U2502.R20 (VSS), U2502.R26 (VSS), U2502.T20 (VSS), U2502.U2 (VSS), U2502.U9 (VSS), U2502.V9 (VSS), U2502.V10 (VSS), U2502.V19 (VSS), U2502.W3 (VSS), U2502.W10 (VSS), U2502.W13 (VSS), U2502.W14 (VSS), U2502.W17 (VSS), U2502.W19 (VSS), U2502.W25 (VSS), U2502.Y12 (VSS), U2502.Y13 (VSS), U2502.Y17 (VSS), U2502.Y25 (VSS); also elsewhere on the board
VSSA_DAC: U2502.Y26 (VSSA_DAC)
VSS_CSI2: U2502.AG16 (VSS_CSI2)
VSS_CSIB: U2502.M28 (VSS_CSIB)
VSS_DSI: U2502.AH21 (VSS_DSI)
VSS_SDI: U2502.AA26 (VSS_SDI)

Notes on the sheet:
Camera
(c) 2014 Golden Delicious Computers GmbH&Co. KG. Licensed under CC-BY-SA.
Main Camera
INCOMPLETE in V2
V2b
Front camera (display connector)

Schematic: GTA04b7.sch, sheet 31

Parts:
C3101, C3102: 470n; SMD-0402
C3103: 1u; SMD-0402
LED3101, LED3102: LED-RGB-SMLP36; SMLP36RGB2W3
P-DISP3709: N900-DISPLAY; 500024-6471
U3101: LP55231; QFN-24+E-0.5

Connections:
32KHZ_UPPER: U3101.6 (CLK)
GND3: C3103.2, LED3101.4 (K), LED3101.5 (K), LED3101.6 (K), LED3102.4 (K), LED3102.5 (K), LED3102.6 (K), P-DISP3709.64 (K), U3101.4 (GND), U3101.10 (TRIG), U3101.20 (ASEL0), U3101.21 (ASEL1), U3101.EXP (GND); also elsewhere on the board
GPIO-LED-EN_UPPER: U3101.5 (EN)
GPIO-RGB-INT_UPPER: U3101.7 (INT)
I2C3-SCL-CPU: U3101.9 (SCL); also elsewhere on the board
I2C3-SDA-CPU: U3101.8 (SDA); also elsewhere on the board
unnamed: P-DISP3709.61 (AB), U3101.13 (D7)
unnamed: P-DISP3709.63 (AG), U3101.14 (D6)
unnamed: LED3101.2 (A), U3101.19 (D1)
unnamed: LED3101.3 (A), U3101.18 (D2)
unnamed: LED3101.1 (A), U3101.17 (D3)
unnamed: LED3102.2 (A), U3101.16 (D4)
unnamed: LED3102.3 (A), U3101.12 (D8)
unnamed: LED3102.1 (A), U3101.11 (D9)
unnamed: C3101.1, U3101.2 (C1+)
unnamed: C3101.2, U3101.24 (C1-)
unnamed: C3102.1, U3101.1 (C2+)
unnamed: C3102.2, U3101.23 (C2-)
unnamed: C3103.1, U3101.22 (VOUT)
unnamed: P-DISP3709.62 (AR), U3101.15 (D5)
VSYS_UPPER: U3101.3 (VDD); also elsewhere on the board

Notes on the sheet:
LEDs
(c) 2014 Golden Delicious Computers GmbH&Co. KG. Licensed under CC-BY-SA.
note: D7, D8, D9 are powered differently!
checkme: assignment of LED location to output number
Addr: 0x32
AUX and Display LEDs
V2b
RGB LEDs (display connector)

Schematic: GTA04b7.sch, sheet 32

Parts:
C3201, C3203: 2u2; SMD-0402
C3202, C3204, C3207, C3208: 100n; SMD-0402
C3205, C3206: 1u; SMD-0402
D3201, D3202: RSX101M-30; CRS02
L3201, L3202: 4u7; SMD-0806
LED3201, LED3202, LED3203, LED3204, LED3205, LED3208: LED-RGB-COMMON-A-MSL0201RGB; MSL0201RGB
LED3206: LED-RGB-SMLP36; SMLP36RGB2W3
LED3207: LTST-C190KRKT; SMD-0603D
LED3209: LTST-C190KFKT; SMD-0603D
LED3210: LTST-C190TBKT; SMD-0603D
R3201, R3202, R3203, R3204: tbd.; SMD-0402
U3201, U3202: LP55281YZR; YZR0036

Connections:
1V8-CPU: U3201.C3 (VIO), U3202.C3 (VIO); also elsewhere on the board
CHG_IND: LED3210.K, U3202.E1 (B); also elsewhere on the board
GND3: C3201.2, C3202.2, C3203.2, C3204.2, C3205.1, C3206.1, C3207.1, C3208.1, R3201.1, R3202.1, R3203.1, R3204.1, U3201.A5 (GND), U3201.B2 (IFSEL), U3201.C4 (SI/A0), U3201.D1 (GND), U3201.E4 (GND), U3201.F1 (GND), U3201.F4 (GND), U3201.F5 (GND), U3202.A5 (GND), U3202.B2 (IFSEL), U3202.C4 (SI/A0), U3202.D1 (GND), U3202.E4 (GND), U3202.F1 (GND), U3202.F4 (GND), U3202.F5 (GND); also elsewhere on the board
I2C3-SCL-CPU: U3201.B3 (SCL), U3202.B3 (SCL); also elsewhere on the board
I2C3-SDA-CPU: U3201.C5 (SDA), U3202.C5 (SDA); also elsewhere on the board
LED2503: LED3203.1 (KG), U3201.A3 (G)
LED2504: LED3205.1 (KG), U3201.D5 (G)
LED2505: LED3208.1 (KG), U3201.E2 (G)
LED2507: LED3204.1 (KG), U3202.A3 (G)
unnamed: LED3206.4 (K), U3202.D5 (G)
unnamed: LED3206.5 (K), U3202.E5 (R)
unnamed: LED3206.6 (K), U3202.D6 (B)
unnamed: LED3201.1 (KG), U3201.B6 (G)
unnamed: LED3201.3 (KB), U3201.A6 (B)
unnamed: LED3201.2 (KR), U3201.C6 (R)
unnamed: LED3203.2 (KR), U3201.A4 (R)
unnamed: LED3207.K, U3202.E3 (R)
unnamed: LED3203.3 (KB), U3201.A2 (B)
unnamed: LED3205.2 (KR), U3201.E5 (R)
unnamed: LED3209.K, U3202.E2 (G)
unnamed: LED3205.3 (KB), U3201.D6 (B)
unnamed: LED3208.2 (KR), U3201.E3 (R)
unnamed: LED3208.3 (KB), U3201.E1 (B)
unnamed: LED3202.2 (KR), U3202.C6 (R)
unnamed: LED3202.1 (KG), U3202.B6 (G)
unnamed: LED3202.3 (KB), U3202.A6 (B)
unnamed: LED3204.2 (KR), U3202.A4 (R)
unnamed: LED3204.3 (KB), U3202.A2 (B)
unnamed: D3201.K, LED3201.4 (A), LED3203.4 (A), LED3205.4 (A), LED3208.4 (A), U3201.E6 (FB)
unnamed: D3202.K, LED3202.4 (A), LED3204.4 (A), LED3206.1 (A), LED3206.2 (A), LED3206.3 (A), LED3207.A, LED3209.A, LED3210.A, U3202.E6 (FB)
unnamed: D3201.A, L3201.1, U3201.F6 (SW)
unnamed: D3202.A, L3202.1, U3202.F6 (SW)
unnamed: C3207.2, U3201.C1 (VREF)
unnamed: C3205.2, U3201.B1 (VDDA)
unnamed: R3203.2, U3201.C2 (IRT)
unnamed: R3201.2, U3201.B5 (IRGB)
unnamed: C3206.2, U3202.B1 (VDDA)
unnamed: C3208.2, U3202.C1 (VREF)
NRESWARM-CPU: U3201.F3 (!NRST), U3202.F3 (!NRST); also elsewhere on the board
VSYS_UPPER: C3201.1, C3202.1, C3203.1, C3204.1, L3201.2, L3202.2, U3201.A1 (VDD), U3201.D3 (VDD), U3202.A1 (VDD), U3202.D3 (VDD); also elsewhere on the board

Notes on the sheet:
Fancy LEDs
(c) 2014 Golden Delicious Computers GmbH&Co. KG. Licensed under CC-BY-SA.
Privacy
MOD
Kbd
V2b

Schematic: GTA04b7.sch, sheet 33

Parts:
P3301, P3302, P3303: FH23-39S; FH23-39S-0.3SHW(0.5)
P-MODEM3709: 105017-0001
R3301, R3302, R3303: (0R); SMD-0402

Connections:
GND3: P3303.22, P3303.38, P3303.39, P-MODEM3709.5/GND (GND); also elsewhere on the board
I2C2-SCL-CPU: P3301.38; also elsewhere on the board
I2C2-SDA-CPU: P3301.37; also elsewhere on the board
I2C3-SCL-CPU: P3302.10; also elsewhere on the board
I2C3-SDA-CPU: P3302.11; also elsewhere on the board
MODEM-CPU-D+: P-MODEM3709.3/D+ (D+), R3303.2; also elsewhere on the board
MODEM-CPU-D-: P-MODEM3709.2/D- (D-), R3302.2; also elsewhere on the board
unnamed: P3301.7, P3301.8, P3301.9, P3301.10
unnamed: P3302.4, P3302.5, P3302.6, P3302.7
NRESWARM-CPU: P3301.39; also elsewhere on the board
OTG-CPU-D+: R3303.1; also elsewhere on the board
OTG-CPU-D-: R3302.1; also elsewhere on the board
SHIELD: P-MODEM3709.SH1 (SHIELD), P-MODEM3709.SH2 (SHIELD), P-MODEM3709.SH3 (SHIELD), P-MODEM3709.SH4 (SHIELD); also elsewhere on the board
VAUX3: P3303.37
VAUX4: P3303.36
VBUS-CPU: R3301.1; also elsewhere on the board
VBUS-MODEM-CPU: P-MODEM3709.1/VBUS (VB), R3301.2; also elsewhere on the board
VSYS_UPPER: P3301.1, P3301.2, P3301.3, P3301.4; also elsewhere on the board

Notes on the sheet:
Connector to BB
(c) 2014 Golden Delicious Computers GmbH&Co. KG. Licensed under CC-BY-SA.
Connect to OMAP3 McSPI1, I2C2, MMC2 / some GPIOs
V2b
Connect to OMAP3 Camera
P2301
P2303
These connectors allow to "emulate" the DM3730 by connecting a BB-XM
DSS / GPIOs, I2C3
Connect to OMAP3 DSS
P2302
connect to respective CPU-pads
INCOMPLETE
prototype only
connect to BB
by some Micro-USB cable

Schematic: GTA04b7.sch, sheet 34

Parts:
C3401, C3402: 1u; SMD-0603
P3401: BEAGLEBOARD
P3402: FH23-39S; FH23-39S-0.3SHW(0.5)
R3401: 62k1; SMD-0402
R3402: 30k1; SMD-0402
U3401: TPS73701DRB; SON-3X3

Connections:
BB-1V8: P3401.J3$1 (VIO_1V8), P3402.29, U3401.5 (EN); also elsewhere on the board
BB-5V: C3401.1, P3401.J3$2 (DC_5V), P3402.34, P3402.35, U3401.8 (IN); also elsewhere on the board
BB-130: P3401.J3$21 (MMC2CLKO/GPIO130), P3402.6
BB-131: P3401.J3$19 (MMC2CMD/GPIO131), P3402.7
BB-132: P3401.J3$17 (MMC2DAT0/GPIO132), P3402.8
BB-133: P3401.J3$15 (MMC2DAT1/GPIO133), P3402.9
BB-134: P3401.J3$13 (MMC2DAT2/GPIO134), P3402.10
BB-135: P3401.J3$11 (MMC2DAT3/GPIO135), P3402.11
BB-136: P3401.J3$9 (MMC2DAT4/GPIO136), P3402.12
BB-137: P3401.J3$7 (MMC2DAT5/GPIO137), P3402.13
BB-138: P3401.J3$5 (MMC2DAT6/GPIO138), P3402.14
BB-139: P3401.J3$3 (MMC2DAT7/GPIO139), P3402.15
BB-143: P3401.J3$8 (MCBSP3FSX/UART2RX/GPIO143), P3402.17
BB-144: P3401.J3$4 (UART2CTS/GPT9/GPIO144), P3402.18
BB-145: P3401.J3$10 (UART2RTS/GPT10/GPIO145), P3402.19
BB-146: P3401.J3$6 (UART2TX/GPT11/GPIO146), P3402.20
BB-156: P3401.J3$20 (MCBSP1CLKR/GPIO156), P3402.22
BB-157: P3401.J3$22 (MCBSP1FSR/GPIO157), P3402.23
BB-158: P3401.J3$12 (MCBSP1DX/GPIO158), P3402.24
BB-159: P3401.J3$18 (MCBSP1DR/GPIO159), P3402.25
BB-161: P3401.J3$16 (MCBSP1FSX/GPIO161), P3402.27
BB-162: P3401.J3$14 (MCBSP1CLKX/GPIO162), P3402.28
BB-I2C2SCL: P3401.J3$24 (I2C2SCL/GPIO168), P3402.2
BB-I2C2SDA: P3401.J3$23 (I2C2SDA/GPIO183), P3402.3
BB-NRESWARM: P3401.J3$26 (!RESET), P3402.1
BB-VSYS: C3402.1, P3402.36, P3402.37, P3402.38, P3402.39, R3401.2, U3401.1 (OUT)
GND4: C3401.2, C3402.2, P3401.J3$27 (GND), P3401.J3$28 (GND), P3402.30, P3402.31, P3402.32, P3402.33, R3402.1, U3401.4 (GND), U3401.9 (GND), U3401.10 (GND), U3401.11 (GND), U3401.12 (GND), U3401.13 (GND); also elsewhere on the board
unnamed: R3401.1, R3402.2, U3401.3 (NR/FB)

Notes on the sheet:
BB-XM Adapter (CPU)
(c) 2014 Golden Delicious Computers GmbH&Co. KG. Licensed under CC-BY-SA.
reverse?
3.7V (VSYS/VBATT)
V2b
P2401
check visually during layout phase
Ersetzen durch 2A buck converter

Notices in the files:
ee/cvt/modified_eagle_files/GTA04b7.sch:
(c) 2015 Golden Delicious Computers GmbH&Co. KG. Licensed under CC-BY-SA.
